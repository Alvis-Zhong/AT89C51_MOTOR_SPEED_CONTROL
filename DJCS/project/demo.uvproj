# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user\bsp_lcd;..\user\bsp_motor;..\user
  group LCD
    ../user/bsp_lcd/: bsp_lcd1602.c
  group MOTOR
    ../user/bsp_motor/: bsp_motor.c
  group MAIN
    ../user/: main.c main.h
